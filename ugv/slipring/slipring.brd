File: ugv/slipring/slipring.brd (EAGLE design)
At the start: 52.5 x 49 mm, 1 part

Commit message: before ugv v1
Routing:
- net N1: track 144.3 -> 141.7 mm
- net P1: track 117.9 -> 120.5 mm
